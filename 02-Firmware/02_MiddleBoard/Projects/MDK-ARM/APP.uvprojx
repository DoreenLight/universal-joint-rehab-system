# Keil uVision project APP.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Driver\Timer;..\..\Service\CRC;..\..\Service\Flash_Internal;..\..\User;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Driver\CAN;..\..\User\CanUpgrade;..\..\Driver\USART;..\..\User\UartUpgrade;..\..\Service\extern_device;..\..\Driver\mx25L1606E;..\..\Driver\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../User/: main.c Timer_pro.c
  group Service
    ../../Service/CRC/: crc16.c
    ../../Service/Flash_Internal/: flash_internal.c
    ../../Service/extern_device/: extern_device_control.c
  group Driver
    ../../Driver/Timer/: Timer.c
    ../../Driver/USART/: usart1.c usart3.c usart4.c
    ../../Driver/mx25L1606E/: mx25L1606E.c
    ../../Driver/SPI/: Flash_spi.c
  group SYSTEM
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
    ../../User/: stm32g4xx_it.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_fdcan.c
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
